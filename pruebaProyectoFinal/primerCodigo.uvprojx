# Keil uVision project primerCodigo.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: primerCodigo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: oty.c UART0.c UART0.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 1.0.0
